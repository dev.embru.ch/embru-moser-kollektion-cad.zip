Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.1]
File name: Moser Kollektion.ifc
Time: 2022-02-15T14:28:09
Written by: pCon.planner

# IfcBuilding
ElevationOfRefHeight: 0 m; ElevationOfTerrain: 0 m

# IfcBuildingStorey
Elevation: 0 m

# IfcFurniture (4)
Pset_ManufacturerTypeInformation - Manufacturer: Embru Klassiker
Name | Description | ArticleNumber
Moser Fauteuil Modell 1435 | Moser Fauteuil Modell 1435 Modell 1435 Werner Max Moser, Entwurf 1930 | 1020100
Moser Hochlehner Modell 1437 | Moser Hochlehner Modell 1437 Modell 1437 Werner Max Moser, Entwurf 1932 | 1020101
Moser Sofa 3er Modell 1438 | Moser Sofa 3er Modell 1438 | 1020106
Moser Hocker Modell 1552 | Moser Hocker Modell 1552 Modell 1552 Werner Max Moser, Entwurf 1930 | 1020102
